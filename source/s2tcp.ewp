# IAR project s2tcp.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AT32F413CBT7_v2 ArteryTek -AT32F413CBT7
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: AT32F413CBT7
  ICCARM.CCIncludePath2: ; hw_config/inc/; app/inc/; lib/inc/; drivers/AT32F413_HAL_Driver/inc; drivers/AT32F413_CMSIS_Driver/; drivers/w5500/inc/; external/ModbusSlave/include; external\RingFIFO\include\; external\SerialRingBuffer\include\; external\SerialRingBuffer\port\at32f413\inc\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: s2tcp.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG; AT32F413RCT7
  ICCARM.CCIncludePath2: ; config/; AT32F413_CMSIS_Driver/; app/inc/; project/inc/; lib/inc/; ports/lcvm/inc/; ../external/AT32F413_HAL_Driver/inc; ../external/lcvm/include; ../external/binex-lib/include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ILINK.IlinkIcfFile: Linker.icf
  group (top)
    ./: at32f413_conf.h version.h
  group app/inc
    app/inc/: app_bridge.h modbus_reg_model.h modbus_slave_config.h modbus_tcp_server.h system_clock.h tcp_uart_bridge.h
  group app/src
    app/src/: app_bridge.c main.c modbus_reg_model.c modbus_tcp_server.c system_clock.c tcp_uart_bridge.c
  group drivers/AT32F413_CMSIS_Driver
    drivers/AT32F413_CMSIS_Driver/: at32f413.h system_at32f413.c system_at32f413.h
    drivers/AT32F413_CMSIS_Driver/startup/iar/: startup_at32f413.s
  group drivers/AT32F413_HAL_Driver
    drivers/AT32F413_HAL_Driver/src/: at32f413_acc.c at32f413_adc.c at32f413_bpr.c at32f413_can.c at32f413_crc.c at32f413_crm.c at32f413_debug.c at32f413_dma.c at32f413_exint.c at32f413_flash.c at32f413_gpio.c at32f413_i2c.c at32f413_misc.c at32f413_pwc.c at32f413_rtc.c at32f413_sdio.c at32f413_spi.c at32f413_tmr.c at32f413_usart.c at32f413_usb.c at32f413_wdt.c at32f413_wwdt.c
  group drivers/w5500/inc
    drivers/w5500/inc/: w5500.h w5500_def.h w5500_exchange.h w5500_port.h w5500_raw_socket.h w5500_socket.h w5500_tcp_server.h
  group drivers/w5500/src
    drivers/w5500/src/: w5500.c w5500_exchange.c w5500_port.c w5500_raw_socket.c w5500_socket.c w5500_tcp_server.c
  group external/ModbusSlave
    external/ModbusSlave/src/: modbus_slave_ethernet.c modbus_slave_pdu_parser.c
  group external/RingFIFO
    external/RingFIFO/src/: RingFIFO.c
  group external/SerialRingBuffer
    external/SerialRingBuffer/src/: serial_ring_buffer.c
    external/SerialRingBuffer/port/at32f413/src/: serial_ring_buffer_hal.c
  group hw_config/inc
    hw_config/inc/: hw_adc_config.h hw_config.h hw_dma_config.h hw_gpio_config.h hw_spi_config.h hw_timer_config.h hw_uart_config.h systick.h
  group hw_config/src
    hw_config/src/: hw_adc_config.c hw_config.c hw_dma_config.c hw_gpio_config.c hw_interrupts.c hw_spi_config.c hw_timer_config.c hw_uart_config.c systick.c
  group lib/inc
    lib/inc/: crc8.h
  group lib/src
    lib/src/: crc8.c
